# Keil uVision project EdgeInterrupt.uvproj, settings and files
target EdgeInterrupt (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: EdgeInterrupt
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;..\..\ARM\INC\TI\TM4C123
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s EdgeInterrupt.c Nokia5110.c mq-3.c
  group headers
    ./: Nokia5110.h mq-3.h
